# IAR project main_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VE ST STM32F205VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=8000000; _DEBUG
  ICCARM.CCIncludePath2: aw_source; $PROJ_DIR$; aw_source\hl_STM32F205_qts; aw_source\stdlib_stm32f2xx\inc; aw_source\hl_STM32F205_qts\CMSIS\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: main_app.hex
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: aw_source\hl_STM32F205_qts\CMSIS\DeviceSupport\stm32f205VE_flash.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; HSE_VALUE=8000000
  group app/inc
    main/app/inc/: app.h app_lids.h app_main.h app_qts_public.h app_words.h eh_app.h eh_app_main.h eh_calibration_set.h eh_data_mod.h eh_drop.h eh_mop_app.h mrun_app.h
  group app/src
    main/app/src/: app_words.c aw_main.c eh_app_main.c eh_calibration_set.c eh_drop.c eh_mop_app.c mrun_app.c version.c
  group app_layer/inc
    main/app_layer/inc/: app_layer.h p_alarm.h p_alarm_blub.h p_alarm_lamps.h p_alarm_over.h p_alarm_tmout.h p_alarm_warn.h p_alarm_wt.h p_auxio.h p_calib_adjust.h p_calib_bimc.h p_calib_eag.h p_calib_empty.h p_calib_eorh.h p_calib_hag.h p_calib_heavy.h p_calib_man.h p_calib_needed.h p_comms.h p_demo.h p_diag_almlights.h p_diag_almstatus.h p_diag_caldata.h p_diag_caldata2.h p_diag_calib.h p_diag_calstat.h p_diag_reset.h p_diag_sdata.h p_diag_sensor.h p_diag_top.h p_diag_version.h p_display.h p_language.h p_lcd_wb.h p_macro.h p_mmenu.h p_pin_cq.h p_pin_create.h p_pin_enter.h p_reset_ays.h p_rs485_mode.h p_sel_sensor.h p_sel_ts.h p_settings.h p_setup.h p_splash.h p_tc_test.h p_test_almlights.h p_tnum.h p_ts_companies.h p_turn_off.h p_weight.h p_wizard_ays.h p_wunits.h psc_di.h
  group app_layer/src
    main/app_layer/src/: app_layer.c p_alarm.c p_alarm_blub.c p_alarm_lamps.c p_alarm_over.c p_alarm_tmout.c p_alarm_warn.c p_alarm_wt.c p_auxio.c p_calib_adjust.c p_calib_bimc.c p_calib_eag.c p_calib_empty.c p_calib_eorh.c p_calib_hag.c p_calib_heavy.c p_calib_man.c p_comms.c p_demo.c p_diag_almlights.c p_diag_almstatus.c p_diag_caldata.c p_diag_caldata2.c p_diag_calstat.c p_diag_reset.c p_diag_sdata.c p_diag_sensor.c p_diag_version.c p_display.c p_isit_eorf.c p_language.c p_lcd_wb.c p_mmenu.c p_pin_cq.c p_pin_create.c p_pin_enter.c p_reset_ays.c p_rs485_mode.c p_sel_config.c p_sel_sensor.c p_sel_ts.c p_settings.c p_setup.c p_splash.c p_tc_test.c p_test_almlights.c p_tnum.c p_ts_companies.c p_turn_off.c p_weight.c p_wizard_ays.c p_wunits.c psc_di.c
  group aw_app/inc
    aw_source/aw_app/inc/: eh_aw_alarm.h eh_aw_app.h eh_aw_app_alarm.h eh_aw_app_dec.h eh_aw_app_led_man.h eh_aw_time.h eh_aw_weight.h eh_datalink.h eh_flashman.h eh_mop_awap.h mop_awap.h mop_awap2.h mrun_awapp.h mrun_tests.h neh_aw_app.h rsfsknet.h skybitz.h
  group aw_app/src
    aw_source/aw_app/src/: aw_app_layer_qlts.c eh_aw_alarm.c eh_aw_app.c eh_aw_app_alarm.c eh_aw_app_led_man.c eh_aw_weight.c eh_datalink.c eh_flashman.c eh_mop_awap.c mop_awap.c mop_awap2.c mrun_awapp.c mrun_tests.c rsfsknet.c skybitz.c
  group awop_layer/inc
    aw_source/awop_layer/inc/: aw_awop_layer.h aw_awws.h aw_calib.h aw_calib_data.h aw_pin.h aw_setup.h awad.h awad_get.h awad_get_std.h awad_set.h awad_set_std.h awad_std.h awas.h awop.h awop_get.h awop_get2.h awop_get3.h awop_set.h awop_set2.h awop_struct.h awop_udata.h awsad_sd.h awsad_swi.h awsd.h axgrp.h axgrp_ds.h axgrp_get.h axgrp_man.h axgrp_model.h axgrp_set.h eh_awop.h eh_awop2.h eh_awop_dec.h eh_macop.h eh_mop_awop.h eh_mop_awop2.h eh_nvram_tman.h macop.h mop_awop.h mop_nvram.h mrun_awop.h neh_awop.h wgi.h wgi_get.h wgi_set.h wgrp_cfg_set.h
  group awop_layer/src
    aw_source/awop_layer/src/: agi.c aw_awop_layer.c aw_awws.c aw_calib.c aw_pin.c aw_sensor.c aw_setup.c awad.c awad_get.c awad_get_std.c awad_set.c awad_set_std.c awad_std.c awas.c awop.c awop_get.c awop_get2.c awop_get3.c awop_set.c awop_set2.c awsad_swi.c awsd.c axgrp.c axgrp_get.c axgrp_set.c cfg_bag.c eh_awop.c eh_awop2.c eh_mop_awop.c eh_mop_awop2.c langsup.c mop_awop.c mop_awop2.c mop_nvram.c mrun_awop.c tt_config.c wgi.c wgi_get.c wgi_set.c wgrp.c wgrp_cfg_set.c wgrp_get.c wgrp_man.c wgrp_set.c
  group common_layer/inc
    aw_source/common/inc/: appem.h atom_train.h aw_blob.h aw_blob_group.h aw_buf.h aw_common.h aw_common_base.h aw_crc.h aw_gbasic.h aw_general.h aw_idraw.h aw_llh.h aw_llip.h aw_llist.h aw_math.h aw_node.h aw_node_group.h aw_printf.h aw_str.h aws_man.h barometer.h bi.h buffer.h dmc.h lcd_general.h mbag.h random.h rb_word.h ring_bp.h ringbuf.h sm_color.h ssmenu.h temp_adc.h
    aw_source/awop_layer/pinc/: awop_bag.h
  group common_layer/src
    aw_source/common/src/: atom_train.c aw_blob.c aw_blob_group.c aw_buf.c aw_common_base.c aw_crc.c aw_idraw.c aw_llh.c aw_llip.c aw_llip2.c aw_llist.c aw_math.c aw_node.c aw_node_group.c aw_printf.c aw_str.c aws_man.c barometer.c bi.c bufman.c dmc.c mbag.c random.c rb_word.c ring_bp.c ringbuf.c temp_adc.c
  group driver_layer/inc
    aw_source/driver_layer/inc/: d_can.h d_can_tx.h d_usart.h d_usart_tx.h dl_base_qlts.h eh_adc.h eh_bma.h eh_dbug.h eh_driver_layer.h eh_fram.h eh_gapp.h eh_htimer.h eh_lcd.h eh_mop_qlts.h eh_nvram_man.h eh_tc.h eh_usart.h eh_usart_tx.h led.h neh_driver_layer.h
  group driver_layer/src
    aw_source/driver_layer/src/: d_usart.c dl_base.c dl_base_qlts.c eh_adc.c eh_bma.c eh_fram.c eh_gapp.c eh_htimer.c eh_lcd.c eh_mop_dl_qlts.c eh_nvram_man.c eh_tc.c eh_usart.c eh_usart_tx.c
  group eman_layer/inc
    aw_source/eman_layer/inc/: aw_eml_base.h em_asynch.h em_asynch2.h em_awai.h isrem_adc.h isrem_can0_rx.h isrem_can0_rx2.h isrem_can0_stat.h isrem_can0_tx.h isrem_can1_rx.h isrem_can1_rx2.h isrem_can1_stat.h isrem_can1_tx.h isrem_htimer.h isrem_htimer1.h isrem_i2c.h isrem_i2c2.h isrem_spi1.h isrem_spi2.h isrem_spi3.h isrem_systick.h isrem_tc.h isrem_usart0_rx.h isrem_usart0_tx.h isrem_usart1_rx.h isrem_usart1_tx.h
  group eman_layer/src
    aw_source/eman_layer/src/: em_asynch.c em_asynch2.c em_awai.c isrem_adc.c isrem_htimer.c isrem_htimer1.c isrem_i2c.c isrem_i2c2.c isrem_spi1.c isrem_spi2.c isrem_spi3.c isrem_systick.c isrem_tc.c isrem_usart0_rx.c isrem_usart0_tx.c
  group event_layer/inc
    aw_source/event_layer/inc/: aw_el.h aw_el_base.h aw_obj.h aw_obj_group.h aw_time.h aw_timer.h awti.h eh_aw_event_layer.h eh_emop.h eh_emop_el.h eh_emops.h eh_logmsg.h eh_mman.h eh_mrun.h ehandler.h ehi.h ehi2.h ehi_state.h ehp.h ei_qman.h eii.h eip.h el_atom_train.h el_tdefs.h em_asynch.h em_asynch2.h em_awai.h em_critical.h event.h event_bi.h eventman.h evsup.h isrem_adc.h isrem_can0_rx.h isrem_can0_rx2.h isrem_can0_stat.h isrem_can0_tx.h isrem_can1_rx.h isrem_can1_rx2.h isrem_can1_stat.h isrem_can1_tx.h isrem_htimer.h isrem_i2c.h isrem_i2c2.h isrem_spi1.h isrem_spi2.h isrem_spi3.h isrem_systick.h isrem_tc.h isrem_usart0_rx.h isrem_usart0_tx.h isrem_usart1_rx.h isrem_usart1_tx.h neh_event_layer.h notify.h notify_bgs.h syslog.h
  group event_layer/pinc
    aw_source/event_layer/pinc/: awti_bg.h el_bag.h p_ehandler.h p_event.h
  group event_layer/src
    aw_source/event_layer/src/: aw_el.c aw_el_base.c aw_obj.c aw_obj_group.c aw_time.c aw_timer.c awti.c awti_bg.c eh_emop.c eh_emop_el.c eh_emops.c eh_mman.c eh_mrun.c ehandler.c ehi.c ehi_state.c ehp.c ei_qman.c eii.c eip.c em_critical.c event.c eventman.c evsup.c notify.c notify_bgs.c syslog.c
  group gui_bmp_layer/inc
    main/gui_bmp_layer/inc/: bmp_images.h
  group gui_bmp_layer/src
    main/gui_bmp_layer/src/: air_sensor.c arrow_left.c arrow_left_dim.c arrow_right.c arrow_right_dim.c assign.c AW_full_logo.c AW_full_logo_smaller.c AW_logo_large.c bell.c black_gear_icon.c blank.c both_bulbs.c bottom_lamp_bell_3.c bulb.c cfg_1ag_1ax.c cfg_1ag_1ax_ap_L_ns.c cfg_1ag_1ax_apap_dual.c cfg_1ag_1ax_apap_dual_cal.c cfg_1ag_1ax_ds.c cfg_1ag_1ax_ds_L_ns.c cfg_1ag_1ax_Lup.c cfg_1ag_1ax_split.c cfg_1ag_2ax.c cfg_1ag_2ax_ap_L_ns.c cfg_1ag_2ax_apap_dual.c cfg_1ag_2ax_apap_dual_cal.c cfg_1ag_2ax_ds.c cfg_1ag_2ax_ds_split.c cfg_1ag_2ax_Lup.c cfg_1ag_2ax_split.c cfg_1ag_2x_ds_L_ns.c cfg_1ag_3ax.c cfg_1ag_3ax_ap.c cfg_1ag_3ax_ap_L_ns.c cfg_1ag_3ax_apap_dual.c cfg_1ag_3ax_apap_dual_cal.c cfg_1ag_3ax_ds.c cfg_1ag_3x_Lup.c cfg_1ag_4ax.c cfg_1ag_4ax_Lup.c cfg_1ag_5ax.c cfg_1ag_hh_2.c cfg_1ag_hh_2x1.c cfg_1ag_hh_2x2.c cfg_1ag_hh_3.c cfg_1ag_hh_3x0.c cfg_1ag_hh_3x1.c cfg_1ag_hh_3x2.c cfg_1ag_hh_3x3.c cfg_1ag_hh_4.c cfg_1ag_hh_4x1.c cfg_1ag_hh_4x2.c cfg_1ag_hh_4x3.c cfg_1ag_hh_5.c cfg_1ag_hh_5x1.c cfg_1ag_hh_5x2.c cfg_1ag_hh_5x3.c cfg_2ag_2ax_apds_L.c cfg_2ag_pay.c cfg_3ag_2ax_aplcds_L.c cfg_3ag_full_1x.c cfg_3ag_full_2x.c check_mark_ok.c checked_box.c checked_box2.c clock_alarm_rev.c comm.c doctor_bag.c down_arrow.c down_hatched_arrow.c DownEscapeArrow.c e_1ag_1ax.c e_1ag_1ax_Lup.c e_1ag_2ax.c e_1ag_2ax_Lup.c e_1ag_3ax.c e_1ag_3ax_Lup.c e_1ag_4ax.c e_1ag_4ax_Lup.c e_1ag_5ax.c e_1ag_hh_2x0.c e_1ag_hh_2x1.c e_1ag_hh_2x2.c e_1ag_hh_3x0.c e_1ag_hh_3x1.c e_1ag_hh_3x2.c e_1ag_hh_3x3.c e_1ag_hh_4x0.c e_1ag_hh_4x1.c e_1ag_hh_4x2.c e_1ag_hh_4x3.c e_1ag_hh_5x2.c e_1ag_hh_5x3.c e_1ag_split.c e_2ag_pay_front.c e_2ag_pay_rear.c e_3ag_full_1ax_both.c e_3ag_full_1ax_front.c e_3ag_full_1ax_rear.c e_3ag_full_2ax_both.c e_3ag_full_2ax_front.c e_3ag_full_2ax_rear.c empty_weight_bmp.c escape_arrow_2.c flashing_bulb_bell_3.c flashing_bulb_weight_fast.c flashing_bulb_weight_slow.c font_2page_ascii.c font_2page_c2.c font_2page_c3.c font_3page_ascii.c font_3page_c2.c font_3page_c3.c font_4page_ascii.c font_4page_c2.c font_4page_c3.c font_7page_ascii.c h_1ag_1ax.c h_1ag_1ax_Lup.c h_1ag_2ax.c h_1ag_2ax_Lup.c h_1ag_3ax.c h_1ag_3ax_Lup.c h_1ag_4ax.c h_1ag_4ax_Lup.c h_1ag_5ax.c h_1ag_hh_2x0.c h_1ag_hh_2x1.c h_1ag_hh_2x2.c h_1ag_hh_3x0.c h_1ag_hh_3x1.c h_1ag_hh_3x2.c h_1ag_hh_3x3.c h_1ag_hh_4x0.c h_1ag_hh_4x1.c h_1ag_hh_4x2.c h_1ag_hh_4x3.c h_1ag_hh_5x2.c h_1ag_hh_5x3.c h_1ag_split.c h_2ag_pay_front.c h_2ag_pay_rear.c h_3ag_full_1ax_both.c h_3ag_full_1ax_front.c h_3ag_full_1ax_rear.c h_3ag_full_2ax_both.c h_3ag_full_2ax_front.c h_3ag_full_2ax_rear.c heavy_weight.c key.c left_bulb_2.c Load_cell.c no_light.c on_alarm_rev.c on_off_alarm_rev.c one_axle.c one_axle_smaller.c one_axle_with_lift.c one_axle_with_lift_smaller.c plus_minus_2.c power_hourglass.c right_arrow.c right_bulb_2.c solid_lamp_bell_3.c spread_axle.c spread_axle_smaller.c talking_head.c three_axle.c three_axle_smaller.c three_axle_with_lift.c three_axle_with_lift_smaller.c trailer.c two_axle.c two_axle_smaller.c two_axle_with_lift.c two_axle_with_lift_smaller.c unchecked_box.c up_arrow.c up_hatched_arrow.c w_1ag_1ax.c w_1ag_1ax_Lup.c w_1ag_2ax.c w_1ag_2ax_Lup.c w_1ag_2ax_split.c w_1ag_3ax.c w_1ag_3ax_Lup.c w_1ag_4ax.c w_1ag_4ax_Lup.c w_1ag_5ax.c w_2ag_pay_front.c w_2ag_pay_rear.c w_3ag_full_1ax_both.c w_3ag_full_1ax_front.c w_3ag_full_1ax_rear.c w_3ag_full_2ax_both.c w_3ag_full_2ax_front.c w_3ag_full_2ax_rear.c wand.c weight_alarm.c weights.c wheels.c wrench.c
  group gui_layer/inc
    aw_source/gui_layer/inc/: eh_gui_dim_lcd.h eh_gui_frame.h eh_gui_layer.h eh_gui_lcd.h eh_gui_mop.h eh_gui_p_doff.h eh_gui_pm.h gui_bmpt.h gui_dill.h gui_dim.h gui_dim_term.h gui_ditem.h gui_ditem_bmp_text.h gui_ditem_icon.h gui_ditem_text.h gui_dllm.h gui_fonts.h gui_idraw.h gui_layer.h gui_panel.h gui_pm.h gui_sup.h gui_sup2.h gui_tb.h gui_toggle.h gui_xbox.h neh_gui_layer.h p_macro.h p_macro_result.h p_mbox.h pstack.h psup.h psup2.h psup_alpha.h psup_list.h psup_num.h psup_tbutton.h psup_toggle.h psup_yesno.h scolor.h ssman.h
  group gui_layer/src
    aw_source/gui_layer/src/: eh_gui_dim_lcd.c eh_gui_frame.c eh_gui_lcd.c eh_gui_mop.c eh_gui_pm.c gui_di2.c gui_di_bmp_text.c gui_di_bmpt.c gui_di_dill.c gui_di_icon.c gui_di_tb.c gui_di_xbox.c gui_dill.c gui_ditem.c gui_dllm.c gui_fonts.c gui_idraw.c gui_layer.c gui_panel.c gui_pm2.c gui_sup.c gui_sup2.c p_doff.c p_macro.c p_macro_result.c p_mbox.c p_passon.c pstack.c psup.c psup2.c psup_hlist.c psup_list.c psup_num.c
  group hdwr_layer/inc
    aw_source/hl_STM32F205_qts/inc/: accel.h adc.h auxio.h aw_bsp_base.h aw_flash.h aw_sensor.h clock.h eh_hdwr_layer.h fram.h gpio.h hdwr_layer.h hdwr_layer_base.h hl_usart.h htimer.h i2c.h lcduc1608.h spi.h systick.h tc_at42qt1110.h
  group hdwr_layer/pinc
    aw_source/hl_STM32F205_qts/pinc/: p_gpio.h
  group hdwr_layer/src
    aw_source/hl_STM32F205_qts/src/: adc.c auxio.c aw_flash.c bma.c fram.c gpio.c hdwr_layer.c hdwr_layer_base.c hl_usart.c htimer.c lcduc1608.c spi.c systick.c tc_at42qt1110.c
  group os_layer/inc
    aw_source/os_layer/inc/: awem.h awem2.h awem_can.h awem_comm.h awem_comm_rx.h awem_comm_tx.h awem_usart.h neh_os_layer.h
  group os_layer/src
    aw_source/os_layer/src/: awem.c awem_comm.c awem_comm_rx.c awem_comm_tx.c
  group os_stm32_layer/inc
    aw_source/os_layer_stm32/pinc/: pl_awem_bag.h
  group os_stm32_layer/src
    aw_source/os_layer_stm32/src/: awem_usart.c pl_awem.c
  group public_layer/inc
    public_layer/inc/: aw_app_layer.h d_layer_base.h event_handles.h gui_panel_ids.h mops.h mops_app.h mops_awap.h mops_awop.h mops_dl.h mops_el.h mops_gl.h mops_mman.h neh.h override.h pl_adc.h public_layer.h
  group public_layer/src
    public_layer/src/: pl.c pl_adc.c
  group stdlib/inc
    aw_source/stdlib_stm32f2xx/inc/: flash_layer.h misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group stdlib/src
    aw_source/stdlib_stm32f2xx/src/: flash_layer.c misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group system/inc
    aw_source/hl_STM32F205_qts/CMSIS/CM3/CoreSupport/: arm_comm.h core_cm3.h
    aw_source/hl_STM32F205_qts/CMSIS/inc/: AW_itm.h stm32f2xx.h stm32f2xx_conf.h stm32f2xx_it.h system_stm32f2xx.h
  group system/src
    aw_source/hl_STM32F205_qts/CMSIS/src/: AW_itm.c startup_stm32f2xx.s stm32f2xx_it.c system_stm32f2xx.c
